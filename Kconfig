## Kconfig
```kconfig
config SECURITY_OR
bool "OR security module"
    default y
help
    Any help text here
```
